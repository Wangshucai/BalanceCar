# Keil uVision project BalanceCar.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWORD\TIME;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWORD\DMP;..\HARDWORD\IIC;..\HARDWORD\MPU6050;..\HARDWORD\EXTI;..\HARDWORD\ANO;..\HARDWORD\OLED;..\HARDWORD\CONTROL;..\USER;..\HARDWORD\NRF
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_it.c
  group HARDWORD
    ../HARDWORD/TIME/: Time.c
    ../HARDWORD/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWORD/MPU6050/: MPU6050.c
    ../HARDWORD/IIC/: IOI2C.c
    ../HARDWORD/EXTI/: exti.c
    ../HARDWORD/ANO/: ANO_DT.c
    ../HARDWORD/OLED/: oled.c
    ../HARDWORD/CONTROL/: control.c
    ../HARDWORD/NRF/: nRF.c spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group LIBRARY
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
